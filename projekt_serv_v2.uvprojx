# Keil uVision project projekt_serv_v2.uvprojx, settings and files
target default (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projekt_serv_v2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\projekt_v2;.\FreeRTOS_TCP;.\application;.\ioLibrary_Driver;.\ioLibrary_Driver\Ethernet;.\ioLibrary_Driver;.\FreeRTOS_TCP\include;.\FreeRTOS_TCP\portable\Compiler\Keil;.\FreeRTOS_TCP\portable\NetworkInterface\STM32Fxx;.\FreeRTOS_TCP\portable\BufferManagement;.\FreeRTOS_TCP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FreeRTOS_TCP
    ./FreeRTOS_TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c FreeRTOSIPConfig.h
    ./FreeRTOS_TCP/portable/BufferManagement/: BufferAllocation_2.c
    ./: NetworkInterface.c
    ./FreeRTOS_TCP/portable/NetworkInterface/STM32Fxx/: stm32f4xx_hal_eth.c
  group application
    ./application/: main.c
  group Ethernet
    ./ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ./ioLibrary_Driver/Ethernet/W5100/: w5100.c w5100.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS Driver:Ethernet:Custom 2.1.0, CMSIS:CORE 5.3.0, CMSIS:RTOS:FreeRTOS 10.3.1, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
